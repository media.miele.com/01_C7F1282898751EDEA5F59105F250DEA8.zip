Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [COBie2.4DesignDeliverable]
File name: 0001
Time: 2023-12-05T14:11:53
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 21.1.21.45 - Exporter 21.1.21.45 - Default UI
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Tue Dec 05 14:11:53 2023 * Host: DEGTL11901 * Database: C:\Users\deschvi\AppData\Local\Temp\74af1b9b-11b5-4196-8cff-dc16fb3d5fb9\7b4b51be-108f-4104-98c3-b30579aa926d\ifc * Database version: 5507 * Database creation date: Tue Dec 05 14:11:52 2023 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Tue Dec 05 14:11:52 2023 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Tue Dec 05 14:11:52 2023 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, 0001
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 mm
Pset_ProductRequirements - Category: Project Information

# IfcBuildingElementProxy: 12463620_TR_KM7466FL:26746670_TR_12463620_KM7466FL, (2)
In: Default
Type - Material: z_Miele_Design_CLST
Type - Pset_BuildingElementProxyCommon - Reference: 26746670_TR_12463620_KM7466FL
Type - Pset_ManufacturerTypeInformation - Manufacturer: Miele
Type - Pset_ProductRequirements - Category: Specialty Equipment
Type - Pset_QuantityTakeOff - Reference: 26746670_TR_12463620_KM7466FL
Type - Pset_ProvisionForVoid - Width: 620 mm; Height: 51 mm; Depth: 520 mm
Material: z_Miele_Design_CLST, z_Miele_Design_Glass Black, z_Miele_Connection_Electric, Default
Pset_BuildingElementProxyCommon - sets with these values: 2
